## package/gcc-target2/Config.in
```kconfig
config BR2_PACKAGE_GCC_TARGET2
	bool "gcc_target2"
	help
	  Install gcc on the target
```
